# Keil uVision project Template.uvproj, settings and files
target Lamp (MCS-51)
  device: STC8G1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: Template +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\System;..\Modules;..\User
  group User
    ./: main.c
  group Modules
    ../Modules/: delay.c uart.c str.c pwm.c key.c power.c timer.c eeprom.c
